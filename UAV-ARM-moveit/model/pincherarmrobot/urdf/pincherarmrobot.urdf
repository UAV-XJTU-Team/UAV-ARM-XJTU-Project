Commit message: Add files via upload

File: UAV-ARM-moveit/model/pincherarmrobot/urdf/pincherarmrobot.urdf (robot description, URDF)
Before this commit: robot pincherarmrobot, 9 links, 8 joints
Links:
- added link world
Joints:
- added joint virtual_joint: type fixed, parent world, child base_link
